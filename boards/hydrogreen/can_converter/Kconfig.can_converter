## boards/hydrogreen/can_converter/board.yml
```yaml
board:
  name: can_converter
  full_name: CAN Converter Unit
  vendor: hydrogreen
  socs:
    - name: stm32g491xx
```
